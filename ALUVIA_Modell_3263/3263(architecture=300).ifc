Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_28_4wQtz/format_0/3263(architecture=300).ifc
Time: 2025-09-01T09:05:14
Made in: PARTsolutions

# IfcProject, 3263(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3263(architecture=300)
In: BUILDING
Description: 3263(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3263
ePset_PARTsolutions - NB: 3263(architecture=300); NN: 3263; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3263(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3263; B: 3263_aluvia_1000x1200.png; C: ALUVIA; E: KALDEWEI; EF000049: 1000; EF004567: 1200; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 1200; etim7_EC003246_LENGTH: 1000
